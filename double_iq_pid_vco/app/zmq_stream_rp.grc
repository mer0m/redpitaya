options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: zmq_stream
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 125e6
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_deinterleave_0_1
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate/128
    fc: '0'
    fftsize: 2**10
    grid: 'True'
    gui_hint: 3,0
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: float
    wintype: firdes.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 0,0
    label1: ''
    label2: ''
    nconnections: '2'
    size: 2**11
    srate: samp_rate/8192
    type: float
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://192.168.0.200:9902
    timeout: '200'
    type: short
  states: {}
- name: zeromq_sub_source_0_1
  id: zeromq_sub_source
  parameters:
    address: tcp://192.168.0.200:9901
    timeout: '200'
    type: short
  states: {}

connections:
- [blocks_deinterleave_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_deinterleave_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_deinterleave_0_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_deinterleave_0_1, '1', qtgui_freq_sink_x_1, '1']
- [blocks_short_to_float_0, '0', blocks_deinterleave_0, '0']
- [blocks_short_to_float_0_1, '0', blocks_deinterleave_0_1, '0']
- [zeromq_sub_source_0, '0', blocks_short_to_float_0, '0']
- [zeromq_sub_source_0_1, '0', blocks_short_to_float_0_1, '0']

metadata:
  file_format: 1
